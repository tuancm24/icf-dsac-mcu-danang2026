# Keil uVision project dsac.uvproj, settings and files
target Target 1 (MCS-51)
  device: SN8F5708 SONiX
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0x3FF5) CLOCK(32000000) MODC2 DPC MDU_R515
  output: dsac
  c flags: Optimize=8
  c include: ..\drivers;..\platform;..\config;..\app
  group Startup
    ./: STARTUP.A51
    D:/Keil_v5/C51/INC/SONIX/: OPTIONS_SN8F5708.A51
  group App
    ../app/: main.c clock.c fsm.c alarm.c
  group Drivers
    ../drivers/: button.c buzzer.c display.c led.c eeprom.c button_test.c
  group Platform
    ../platform/: board.c gpio.c timer.c i2c.c
